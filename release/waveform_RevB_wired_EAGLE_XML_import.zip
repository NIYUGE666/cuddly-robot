# EAGLE board waveform (EAGLE 9.6.2), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
AC_SQUARE
  Top 0.25: R3.1 201.5,70 186,70 | 186,70 185.5,70 185.5,68.5 95,68.5 95,60 RV2.1 | C3.2 186,70
  Bottom 0.25: RV2.1 95,60 | R3.1 201.5,70 | C3.2 186,70
CLOCK_2K
  Top 0.25: U1.3 10,65 16,65 16,61 36.5,61 36.5,56 39.5,56 39.5,64 39,64 39,65 | U2.3 38,65 44,65 44,56 148.5,56 148.5,60 TP1.1
  Bottom 0.25: U2.3 38,65 | TP1.1 148.5,60 | U1.3 10,65
CTRL
  Top 0.25: U1.5 17.5,62.5 36.5,62.5 36.5,71.5 119.5,71.5 119.5,72 120,72 120,72.5 166,72.5 166,70 C2.1
  Bottom 0.25: U1.5 17.5,62.5 | C2.1 166,70
D_FEEDBACK
  Top 0.25: U2.5 38,60 | U2.2 38,67.5
  Bottom 0.25: U2.2 38,67.5 36.5,67.5 36.5,61 38,61 38,60 U2.5
DIGITAL_1K  (via drill 0.3 pad 0.6)
  Top 0.25: v38,73.5 166.5,73.5 166.5,73 167,73 167,71.5 172.5,71.5 172.5,70 184,70 C3.1
  Bottom 0.25: v38,73.5 U2.1 | C3.1 184,70
DISCHARGE  (via drill 0.3 pad 0.6)
  Top 0.25: v102.5,75 102.5,74.5 37.5,74.5 37.5,74 37,74 37,72.5 36,72.5 36,72 35.5,72 35.5,67.5 17.5,67.5 U1.7 | R2.1 113,70 102.5,70 R1.2
  Bottom 0.25: R2.1 113,70 | v102.5,75 102.5,70 R1.2 | U1.7 17.5,67.5
FREQ_R
  Top 0.25: RV1.1 130.5,70 129.5,70 129.5,71.5 120.5,71.5 120.5,70 R2.2
  Bottom 0.25: R2.2 120.5,70 | RV1.1 130.5,70
GND  (via drill 0.3 pad 0.6)
  Top 0.25: U2.8 45.5,55 | v76.5,212.5 69,212.5 69,213 v67.5,213 67.5,214 63,214 U7.3 | C52.2 178,204 | C48.2 141,204 140,204 140,203 137,203 137,201 136.5,201 136.5,200.5 136,200.5 136,196 | v187,21.5 203.5,21.5 203.5,23 C28.2 | 30,194.5 30,193 v15.5,193 15.5,193.5 11,193.5 11,194 10.5,194 10.5,196 8,196 C35.1 | RV22.3 185.5,102 | 93.5,163 93.5,160 v87,160 | v76.5,205.5 v82,205.5 82,205 85,205 85,204 86,204 C42.2 | 68,112.5 67,112.5 67,111.5 64.5,111.5 64.5,111 46,111 46,110.5 45.5,110.5 45.5,110 31,110 v31,111 24.5,111 24.5,112.5 13,112.5 C9.2 | 118,214 124,214 124,212.5 125.5,212.5 125.5,211.5 U10.5 | C54.2 196,204 192,204 192,205 v180.5,205 | 68,112.5 68,110.5 70,110.5 70,110 70.5,110 70.5,102 75.5,102 RV12.3 | C21.2 123,112.5 | v158.5,214 153.5,214 U12.3 | C39.1 43.5,196 47,196 47,194.5 60.5,194.5 60.5,194 61,194 61,193.5 63,193.5 v63,193 | U3.5 73.5,62.5 v76.5,62.5 | v108,214 118,214 | C56.2 213.5,204 215,204 215,194.5 198,194.5 198,194 197.5,194 197.5,193.5 191.5,193.5 191.5,194 191,194 191,196 | v32,160 38.5,160 38.5,163 | C55.1 191,196 | U6.3 43.5,214 v49,214 | C47.1 118,196 121.5,196 121.5,197.5 122.5,197.5 v122.5,201 122.5,203 123,203 123,204 C46.2 | v54,204 48.5,204 C38.2 | C27.2 178,112.5 | 208.5,194.5 208.5,196 C57.1 | U13.3 173,214 | C40.2 68,204 68,197.5 66.5,197.5 66.5,196 63,196 C41.1 | 55.5,70 55.5,62.5 45.5,62.5 U2.11 | 29.5,196 26,196 C37.1 | C8.2 31,132.5 | 15,55 15,61 8.5,61 8.5,69 10,69 U1.1 | 206,183.5 206,194.5 | 55.5,70 64.5,70 64.5,61 71,61 v71,60 89.5,60 90,60 RV2.3 | U15.3 208.5,214 | v148.5,132.5 141,132.5 C20.2 | U2.7 38,55 15,55 | RV8.2 96,183.5 93.5,183.5 RV8.3 | C49.1 136,196
  Top 0.25: C31.2 55.5,70 | TP18.1 148.5,23 164.5,23 164.5,21.5 166,21.5 166,20.5 J5.2 | R3.2 209.5,70 203,70 203,71.5 v174,71.5 | C2.2 171,70 | RV3.3 38.5,183.5 41,183.5 RV3.2 | 38.5,163 41,163 RV4.2 | 93.5,163 96,163 RV9.2 | 206,183.5 203.5,183.5 RV18.3 | U7.5 70.5,211.5 70.5,212.5 | v153.5,202 153.5,202.5 155,202.5 155,204 158.5,204 C50.2 | U2.6 38,57.5 | C58.2 15,18 15,11.5 13.5,11.5 13.5,10 10,10 C59.1 | v14.5,28 10,28 U16.3 | RV17.3 130.5,102 | 29.5,196 29.5,203 30,203 30,204 31,204 C36.2 | RV13.2 151,183.5 148.5,183.5 RV13.3 | C44.2 103.5,204 103.5,203 102.5,203 102.5,197.5 102,197.5 102,196 98.5,196 C45.1 | C1.2 153.5,70 | 29.5,196 29.5,194.5 v41,194.5 | RV18.2 206,183.5 | U13.5 180.5,211.5 174.5,211.5 174.5,213 173,213 173,214 | v205,132.5 196,132.5 C26.2 | U16.5 17.5,25.5 | 180.5,193.5 v180.5,193 | v103.5,215 103.5,214 98.5,214 U9.3 | RV19.2 206,163 203.5,163 RV19.3 | 180.5,193.5 187,193.5 187,194 187.5,194 187.5,196 191,196 | U4.5 15.5,211.5 15.5,212.5 14,212.5 14,214 8,214 U4.3 | U2.9 45.5,57.5 | v125.5,200 136,200 | 20.5,112.5 20.5,102 RV7.3 | C15.2 68,112.5 | v178,129 v195.5,129 | U2.4 38,62.5 | 173,214 v164,214 | RV4.3 38.5,163 | v16,52 16,55 | C51.1 153.5,196 142,196 142,194.5 136,194.5 136,196 | C29.1 95,12.5 | RV14.2 151,163 148.5,163 RV14.3 | C14.2 86,132.5 | 180.5,193.5 176,193.5 176,194 175.5,194 175.5,196 173,196 C53.1 | C34.2 13,204 | RV9.3 93.5,163 | v96,193 96,193.5 84,193.5 84,194 83.5,194 83.5,196 81,196 C43.1 | v100,63 v96.5,63 | C30.2 15,55 | v123,121 v140.5,121 | C32.2 71,55 71,48.5 69.5,48.5 69.5,47 66,47 C33.1 | J6.2 184,20.5 | U10.3 118,214
  Bottom 0.25: 171,71 167.5,71 167.5,71.5 164.5,71.5 164.5,70 153.5,70 C1.2 | v14.5,28 16,28 | 171,70.5 174,70.5 v174,71.5 | RV3.2 41,183.5 | 45.5,58.5 47,58.5 47,62.5 45.5,62.5 U2.11 | v164,214 163.5,214 163.5,214.5 163,214.5 163,215 162.5,215 162.5,220.5 159.5,220.5 159.5,214 v158.5,214 158.5,204 C50.2 | C48.2 141,204 | v195.5,129 195.5,132.5 196,132.5 C26.2 | v148.5,132.5 148.5,163 RV14.3 | RV12.3 75.5,102 76.5,102 v76.5,62.5 89.5,62.5 89.5,60 | 45.5,57.5 45.5,55 U2.8 | v122.5,201 125,201 125,200.5 125.5,200.5 v125.5,200 | v203.5,70 203.5,23 C28.2 | v63,193 63,196 C41.1 | 185.5,102 185.5,112.5 178,112.5 | RV13.2 151,183.5 | v49,214 49,220.5 52.5,220.5 52.5,214 53,214 53,213.5 53.5,213.5 53.5,204 v54,204 v54,194.5 | U6.3 43.5,214 | C31.2 55.5,70 | C20.2 141,132.5 140.5,132.5 v140.5,121 | v31,111 31,132.5 | C15.2 68,112.5 | v108,214 107.5,214 107.5,220.5 104.5,220.5 104.5,215 v103.5,215 103.5,204 C44.2 | RV4.2 41,163 41,183.5 | C43.1 81,196 82,196 v82,205.5 | RV17.3 130.5,102 130.5,112.5 123,112.5 | C38.2 48.5,204 | U9.3 98.5,214 | C56.2 213.5,204 | RV7.3 20.5,102 | RV14.2 151,163 151,183.5 | C21.2 123,112.5 | U10.5 125.5,211.5 125.5,204 123,204 C46.2 | v187,21.5 184,21.5 184,20.5 | C45.1 98.5,196 96,196 96,183.5 | 184,20.5 166,20.5 J5.2 | RV18.2 206,183.5 206,163 RV19.2 | v205,132.5 205,163 203.5,163 RV19.3 | 31,132.5 31,151.5 32,151.5 v32,160 | 123,112.5 v123,121 | C34.2 13,204 15.5,204 | RV8.2 96,183.5 | C30.2 15,55 | RV2.3 90,60 91,60 91,61 92.5,61 92.5,65.5 93,65.5 93,66 94,66 94,65.5 94.5,65.5 94.5,63 v96.5,63 | U13.5 180.5,211.5 | U7.5 70.5,211.5 | C14.2 86,132.5 86,151.5 87,151.5 v87,160 | C35.1 8,196 | 16,26.5 15,26.5 15,18 C58.2
  Bottom 0.25: C40.2 68,204 68,213 v67.5,213 | C27.2 178,112.5 | C42.2 86,204 | 185.5,102 174.5,102 174.5,90.5 171,90.5 171,70 C2.2 | 45.5,58.5 44,58.5 44,60 43.5,60 43.5,60.5 43,60.5 43,62.5 38,62.5 U2.4 | C29.1 95,12.5 95,11 98.5,11 98.5,29 99,29 99,29.5 99.5,29.5 99.5,63 v100,63 | C39.1 43.5,196 41,196 41,183.5 | U2.7 38,55 38,57.5 | v76.5,212.5 v76.5,205.5 | RV4.3 38.5,163 | U16.3 10,28 | RV3.3 38.5,183.5 | RV22.3 185.5,102 | C33.1 66,47 | 16,26.5 17.5,26.5 17.5,25.5 U16.5 | U2.9 45.5,57.5 | 15.5,204 v15.5,193 | RV8.3 93.5,183.5 | U3.5 73.5,62.5 | RV18.3 203.5,183.5 | 45.5,57.5 45.5,58.5 | U4.3 8,214 | U10.3 118,214 | C57.1 208.5,196 208.5,202.5 207,202.5 207,213 208.5,213 208.5,214 U15.3 | v180.5,205 180.5,204 | C53.1 173,196 | U7.3 63,214 | C55.1 191,196 | TP18.1 148.5,23 | 16,26.5 v16,52 | C37.1 26,196 | v71,60 71,55 C32.2 | 178,112.5 v178,129 | v153.5,202 153.5,196 C51.1 | J6.2 184,20.5 | C52.2 178,204 | C8.2 31,132.5 | 151,183.5 v151,196 | 96,183.5 96,163 RV9.2 | C47.1 118,196 | 39.5,62.5 39.5,58.5 38,58.5 38,57.5 | RV9.3 93.5,163 | U2.6 38,57.5 | U12.3 153.5,214 | U13.3 173,214 | C9.2 13,112.5 | C36.2 31,204 | U4.5 15.5,211.5 15.5,204 | C59.1 10,10 | 180.5,204 178,204 | 178,204 v178,211.5 | C49.1 136,196 | R3.2 209.5,70 | C54.2 196,204 | v180.5,193 180.5,204 | RV13.3 148.5,183.5
H1_AMPLITUDE  (via drill 0.3 pad 0.6)
  Top 0.25: v23,210 51,210 51,211.5 U6.5 | RV7.2 23,102
  Bottom 0.25: U6.5 51,211.5 | RV7.2 23,102 v23,210
H1_AP1  (via drill 0.3 pad 0.6)
  Top 0.25: R13.1 26,143 | R15.1 43.5,132.5 32,132.5 32,131 v27.5,131 | U5.1 26,219 | R17.1 26,122.5
  Bottom 0.25: 26,143 26,151.5 24.5,151.5 24.5,219 26,219 U5.1 | v27.5,131 27.5,131.5 27,131.5 | R17.1 26,122.5 26,131 27,131 27,143 26,143 | R13.1 26,143 | R15.1 43.5,132.5
H1_AP2  (via drill 0.3 pad 0.6)
  Top 0.25: R18.1 26,112.5 | v27.5,121 14,121 14,122.5 8,122.5 R16.1 | v29.5,215 32,215 32,215.5 33.5,215.5 33.5,216.5 U5.7 | J1.1 8,102
  Bottom 0.25: TP5.1 8,95.5 6.5,95.5 6.5,102 8,102 | J1.1 8,102 | v29.5,215 29.5,132 29,132 29,131.5 28.5,131.5 28.5,130.5 28,130.5 28,130 27,130 27,121 26,121 26,112.5 R18.1 | R16.1 8,122.5 9.5,122.5 9.5,111 8,111 8,102 | v27.5,121 27.5,122 27,122 | U5.7 33.5,216.5
H1_APINV1
  Top 0.25: U5.2 26,216.5 | R12.2 15.5,143 24.5,143 24.5,141.5 33.5,141.5 33.5,143 R13.2
  Bottom 0.25: R13.2 33.5,143 33.5,161.5 32,161.5 32,216.5 26,216.5 U5.2 | R12.2 15.5,143
H1_APINV2
  Top 0.25: R15.2 51,132.5 51,125 33,125 33,124.5 32.5,124.5 32.5,124 24.5,124 24.5,122.5 15.5,122.5 R16.2 | U5.6 33.5,214
  Bottom 0.25: U5.6 33.5,214 42,214 42,210 47,210 47,151.5 49.5,151.5 49.5,141.5 51,141.5 51,132.5 R15.2 | R16.2 15.5,122.5
H1_BPF1
  Top 0.25: C4.2 31,173.5 27,173.5 27,172 8,172 8,173.5 R8.1 | R9.1 8,163
  Bottom 0.25: U4.1 6.5,219 6.5,182 8,182 8,173.5 | 8,173.5 8,163 R9.1 | R8.1 8,173.5 | C4.2 31,173.5
H1_BPF2
  Top 0.25: R12.1 8,143 | U4.7 15.5,216.5 | C6.2 31,153 | 31,153 27,153 27,151.5 8,151.5 8,153 R11.1 | TP4.1 43.5,102 | 31,153 31,144.5 35,144.5 35,143 43.5,143 R14.1
  Bottom 0.25: R14.1 43.5,143 45,143 45,111 43.5,111 43.5,102 TP4.1 | U4.7 15.5,216.5 9.5,216.5 9.5,161.5 8,161.5 8,153 | R12.1 8,143 8,153 | C6.2 31,153 | R11.1 8,153
H1_INV1  (via drill 0.3 pad 0.6)
  Top 0.25: R8.2 15.5,173.5 15.5,174.5 45,174.5 45,173.5 48.5,173.5 C5.2 | v11.5,215 9.5,215 9.5,215.5 8,215.5 8,216.5 U4.2
  Bottom 0.25: C5.2 48.5,173.5 | v11.5,215 11.5,194.5 14,194.5 14,182 15.5,182 15.5,173.5 R8.2 | U4.2 8,216.5
H1_INV2
  Top 0.25: C7.2 48.5,153 45,153 45,154.5 15.5,154.5 15.5,153 R11.2 | U4.6 15.5,214
  Bottom 0.25: U4.6 15.5,214 17,214 17,161.5 15.5,161.5 15.5,153 R11.2 | C7.2 48.5,153
H1_LP1  (via drill 0.3 pad 0.6)
  Top 0.25: U5.3 26,214 | 5.5,132.5 3,132.5 RV5.3 | C8.1 26,132.5 | 5.5,132.5 6.5,132.5 6.5,131.5 26,131.5 26,132.5 | 26,132.5 v28.5,132.5 | RV5.2 5.5,132.5
  Bottom 0.25: v28.5,132.5 28.5,214 26,214 U5.3 | RV5.2 5.5,132.5 | C8.1 26,132.5 | RV5.3 3,132.5
H1_LP2  (via drill 0.3 pad 0.6)
  Top 0.25: U5.5 33.5,211.5 | RV6.3 38.5,122.5 | RV6.2 41,122.5 38.5,122.5 | C9.1 8,112.5 11.5,112.5 11.5,114 35.5,114 v35.5,122.5 38.5,122.5
  Bottom 0.25: v35.5,122.5 35.5,211.5 33.5,211.5 U5.5 | C9.1 8,112.5 | RV6.3 38.5,122.5 | RV6.2 41,122.5
H1_NEG  (via drill 0.3 pad 0.6)
  Top 0.25: J1.3 8,97 v42,97 | U6.1 43.5,219 43.5,218 42,218 42,212.5 v37,212.5 | R19.1 43.5,112.5
  Bottom 0.25: v37,212.5 37,121 43.5,121 43.5,112.5 | R19.1 43.5,112.5 | U6.1 43.5,219 | J1.3 8,97 | v42,97 42,112.5 43.5,112.5
H1_NODE1  (via drill 0.3 pad 0.6)
  Top 0.25: C4.1 26,173.5 | C5.1 43.5,173.5 32,173.5 32,172 28,172 28,171.5 27.5,171.5 27.5,171 26,171 v26,170.5 | R7.1 26,183.5 15.5,183.5 R6.2
  Bottom 0.25: 26,173.5 26,183.5 R7.1 | R6.2 15.5,183.5 | C5.1 43.5,173.5 | v26,170.5 26,173.5 | C4.1 26,173.5
H1_NODE2  (via drill 0.3 pad 0.6)
  Top 0.25: C6.1 26,153 | R10.1 26,163 15.5,163 R9.2 | C7.1 43.5,153 | v43.5,156 v26,156
  Bottom 0.25: C6.1 26,153 26,163 R10.1 | v43.5,156 43.5,153 C7.1 | R9.2 15.5,163
H1_OUT  (via drill 0.3 pad 0.6)
  Top 0.25: TP6.1 26,92 v53.5,92 | U6.6 51,214 | U6.7 51,216.5 | v26,33 R62.1
  Bottom 0.25: 51,214 51,216.5 U6.7 | U6.6 51,214 | v26,33 26,92 TP6.1 | 51,214 51,213 52.5,213 52.5,145.5 53,145.5 53,145 53.5,145 v53.5,92
H1_PHR1
  Top 0.25: RV5.1 8,132.5 24.5,132.5 24.5,134 51,134 51,143 R14.2
  Bottom 0.25: RV5.1 8,132.5 | R14.2 51,143
H1_PHR2
  Top 0.25: R17.2 33.5,122.5 33.5,124 42.5,124 42.5,122.5 43.5,122.5 RV6.1
  Bottom 0.25: RV6.1 43.5,122.5 | R17.2 33.5,122.5
H1_POLINV
  Top 0.25: R19.2 51,112.5 45,112.5 45,111 33.5,111 33.5,112.5 R18.2 | U6.2 43.5,216.5
  Bottom 0.25: R18.2 33.5,112.5 | U6.2 43.5,216.5 43.5,215.5 45,215.5 45,211 47.5,211 47.5,210.5 48,210.5 48,205 50,205 50,152 50.5,152 50.5,144.5 52.5,144.5 52.5,112.5 51,112.5 R19.2
H1_SELECT
  Top 0.25: J1.2 8,99.5 26,99.5 26,102 RV7.1
  Bottom 0.25: RV7.1 26,102 | J1.2 8,99.5
H1_TUNE1
  Top 0.25: R7.2 33.5,183.5 37,183.5 37,182 43.5,182 43.5,183.5 RV3.1
  Bottom 0.25: R7.2 33.5,183.5 | RV3.1 43.5,183.5
H1_TUNE2
  Top 0.25: RV4.1 43.5,163 42.5,163 42.5,164.5 33.5,164.5 33.5,163 R10.2
  Bottom 0.25: R10.2 33.5,163 | RV4.1 43.5,163
H3_AMPLITUDE  (via drill 0.3 pad 0.6)
  Top 0.25: RV12.2 78,102 | U9.5 106,211.5 106,210 v78,210
  Bottom 0.25: v78,210 78,102 RV12.2 | U9.5 106,211.5
H3_AP1  (via drill 0.3 pad 0.6)
  Top 0.25: R27.1 81,143 | U8.1 81,219 | v82.5,131 87,131 87,132.5 98.5,132.5 R29.1 | R31.1 81,122.5
  Bottom 0.25: 81,143 81,151.5 79.5,151.5 79.5,219 81,219 U8.1 | R27.1 81,143 | R31.1 81,122.5 81,131 82,131 82,143 81,143 | R29.1 98.5,132.5 | 82,131.5 82.5,131.5 v82.5,131
H3_AP2  (via drill 0.3 pad 0.6)
  Top 0.25: R32.1 81,112.5 | R30.1 63,122.5 69,122.5 69,121 81,121 v81,120.5 | U8.7 88.5,216.5 84.5,216.5 v84.5,215 | J2.1 63,102
  Bottom 0.25: J2.1 63,102 | v84.5,215 84.5,121 81,121 v81,120.5 81,112.5 R32.1 | R30.1 63,122.5 64.5,122.5 64.5,111 63,111 63,102 | 63,102 61.5,102 61.5,95.5 63,95.5 TP8.1 | U8.7 88.5,216.5
H3_APINV1
  Top 0.25: R26.2 70.5,143 79.5,143 79.5,141.5 88.5,141.5 88.5,143 R27.2 | U8.2 81,216.5
  Bottom 0.25: R27.2 88.5,143 88.5,161.5 87,161.5 87,216.5 81,216.5 U8.2 | R26.2 70.5,143
H3_APINV2  (via drill 0.3 pad 0.6)
  Top 0.25: R30.2 70.5,122.5 79.5,122.5 79.5,124 90,124 v90,131 100,131 100,132.5 106,132.5 R29.2 | U8.6 88.5,214
  Bottom 0.25: v90,131 90,214 88.5,214 U8.6 | R29.2 106,132.5 | R30.2 70.5,122.5
H3_BPF1  (via drill 0.3 pad 0.6)
  Top 0.25: R23.1 63,163 | R22.1 63,173.5 64,173.5 64,174 64.5,174 64.5,174.5 78.5,174.5 78.5,175 79,175 79,175.5 85.5,175.5 v85.5,176 | C10.2 86,173.5
  Bottom 0.25: R23.1 63,163 63,173.5 | v85.5,176 85.5,173.5 86,173.5 C10.2 | R22.1 63,173.5 | U7.1 63,218 61.5,218 61.5,173.5 63,173.5
H3_BPF2  (via drill 0.3 pad 0.6)
  Top 0.25: C12.2 86,153 | v72,155 72,151.5 | R25.1 63,153 63,151.5 82,151.5 82,153 86,153 | R26.1 63,143 | 86,153 86,144.5 90,144.5 90,143 98.5,143 R28.1 | TP7.1 98.5,102 | U7.7 70.5,216.5
  Bottom 0.25: R28.1 98.5,143 100,143 100,111 98.5,111 98.5,102 TP7.1 | C12.2 86,153 | v72,155 72,215.5 70.5,215.5 70.5,216.5 U7.7 | R26.1 63,143 63,153 R25.1
H3_INV1  (via drill 0.3 pad 0.6)
  Top 0.25: U7.2 63,216.5 | 70.5,173.5 79.5,173.5 79.5,174.5 103.5,174.5 103.5,173.5 C11.2 | R22.2 70.5,173.5 | v65,173.5 70.5,173.5
  Bottom 0.25: v65,173.5 64.5,173.5 64.5,215.5 63,215.5 63,216.5 U7.2 | C11.2 103.5,173.5 | R22.2 70.5,173.5
H3_INV2  (via drill 0.3 pad 0.6)
  Top 0.25: 71,155.5 71.5,155.5 71.5,156 103.5,156 103.5,153 C13.2 | R25.2 70.5,153 71,153 71,155.5 | U7.6 70.5,214 | v69,155.5 71,155.5
  Bottom 0.25: R25.2 70.5,153 | v69,155.5 69,185 69.5,185 69.5,205 69,205 69,213 70.5,213 70.5,214 U7.6 | C13.2 103.5,153
H3_LP1  (via drill 0.3 pad 0.6)
  Top 0.25: 60.5,132.5 61.5,132.5 61.5,131.5 81,131.5 81,132.5 | 60.5,132.5 58,132.5 RV10.3 | U8.3 81,214 | 81,132.5 v83.5,132.5 | C14.1 81,132.5 | RV10.2 60.5,132.5
  Bottom 0.25: v83.5,132.5 83.5,214 81,214 U8.3 | C14.1 81,132.5 | RV10.2 60.5,132.5 | RV10.3 58,132.5
H3_LP2  (via drill 0.3 pad 0.6)
  Top 0.25: RV11.2 96,122.5 93.5,122.5 RV11.3 | v92,211.5 88.5,211.5 U8.5 | C15.1 63,112.5 66.5,112.5 66.5,114 v93.5,114
  Bottom 0.25: U8.5 88.5,211.5 | RV11.2 96,122.5 | RV11.3 93.5,122.5 | v92,211.5 92,161.5 93.5,161.5 93.5,122.5 | v93.5,114 93.5,122.5 | C15.1 63,112.5
H3_NEG  (via drill 0.3 pad 0.6)
  Top 0.25: J2.3 63,97 v97,97 | U9.1 98.5,219 | R33.1 98.5,112.5 98.5,114 v102.5,114
  Bottom 0.25: R33.1 98.5,112.5 97,112.5 v97,97 | J2.3 63,97 | U9.1 98.5,219 102,219 102,151.5 102.5,151.5 v102.5,114
H3_NODE1
  Top 0.25: R21.1 81,183.5 70.5,183.5 R20.2 | C10.1 81,173.5 81,172 87,172 87,173.5 98.5,173.5 C11.1
  Bottom 0.25: C10.1 81,173.5 81,183.5 R21.1 | R20.2 70.5,183.5 | C11.1 98.5,173.5
H3_NODE2
  Top 0.25: R24.1 81,163 70.5,163 R23.2 | C13.1 98.5,153 98.5,154.5 84.5,154.5 84.5,154 81.5,154 81.5,153 81,153 C12.1
  Bottom 0.25: R24.1 81,163 81,153 C12.1 | C13.1 98.5,153 | R23.2 70.5,163
H3_OUT  (via drill 0.3 pad 0.6)
  Top 0.25: v104.5,92 81,92 TP9.1 | U9.6 106,214 | U9.7 106,216.5 | R63.1 113,33
  Bottom 0.25: U9.6 106,214 | 106,214 104.5,214 104.5,210 105,210 105,151.5 104.5,151.5 v104.5,92 111.5,92 111.5,58.5 113,58.5 113,33 R63.1 | TP9.1 81,92 | 106,214 106,216.5 U9.7
H3_PHR1
  Top 0.25: RV10.1 63,132.5 79.5,132.5 79.5,134 106,134 106,143 R28.2
  Bottom 0.25: R28.2 106,143 | RV10.1 63,132.5
H3_PHR2
  Top 0.25: RV11.1 98.5,122.5 98.5,121 92,121 92,122.5 88.5,122.5 R31.2
  Bottom 0.25: R31.2 88.5,122.5 | RV11.1 98.5,122.5
H3_POLINV  (via drill 0.3 pad 0.6)
  Top 0.25: R32.2 88.5,112.5 88.5,111 100,111 100,112.5 106,112.5 R33.2 | U9.2 98.5,216.5
  Bottom 0.25: R32.2 88.5,112.5 | U9.2 98.5,216.5 98.5,215.5 100,215.5 100,144 100.5,144 100.5,143.5 101,143.5 101,112.5 v101.5,112.5 | R33.2 106,112.5
H3_SELECT
  Top 0.25: J2.2 63,99.5 81,99.5 81,102 RV12.1
  Bottom 0.25: J2.2 63,99.5 | RV12.1 81,102
H3_TUNE1
  Top 0.25: R21.2 88.5,183.5 92,183.5 92,182 98.5,182 98.5,183.5 RV8.1
  Bottom 0.25: R21.2 88.5,183.5 | RV8.1 98.5,183.5
H3_TUNE2
  Top 0.25: RV9.1 98.5,163 97.5,163 97.5,164.5 88.5,164.5 88.5,163 R24.2
  Bottom 0.25: R24.2 88.5,163 | RV9.1 98.5,163
H5_AMPLITUDE  (via drill 0.3 pad 0.6)
  Top 0.25: RV17.2 133,102 | v133,210 161,210 161,211.5 U12.5
  Bottom 0.25: U12.5 161,211.5 | RV17.2 133,102 v133,210
H5_AP1  (via drill 0.3 pad 0.6)
  Top 0.25: U11.1 136,219 | R43.1 153.5,132.5 | v153.5,124.5 153.5,124 142,124 142,122.5 136,122.5 R45.1 | R41.1 136,143
  Bottom 0.25: U11.1 136,219 136,218 134.5,218 134.5,143 136,143 | R43.1 153.5,132.5 v153.5,124.5 | 136,143 136,134 137,134 137,122.5 136,122.5 R45.1 | R41.1 136,143
H5_AP2  (via drill 0.3 pad 0.6)
  Top 0.25: R44.1 118,122.5 | U11.7 143.5,216.5 | J3.1 118,102 | R46.1 136,112.5 124.5,112.5 124.5,111 v120,111
  Bottom 0.25: 118,102 116.5,102 116.5,95.5 118,95.5 TP11.1 | 119.5,112.5 120,112.5 v120,111 | R46.1 136,112.5 142,112.5 142,215.5 143.5,215.5 143.5,216.5 U11.7 | R44.1 118,122.5 119.5,122.5 119.5,111 118,111 118,102 | J3.1 118,102
H5_APINV1  (via drill 0.3 pad 0.6)
  Top 0.25: R41.2 143.5,143 137,143 | 137,143 137,141.5 125.5,141.5 125.5,143 R40.2 | v137,145 137,143 | U11.2 136,216.5
  Bottom 0.25: U11.2 136,216.5 136,215.5 137,215.5 v137,145 | R41.2 143.5,143 | R40.2 125.5,143
H5_APINV2  (via drill 0.3 pad 0.6)
  Top 0.25: R43.2 161,132.5 155,132.5 155,131 125.5,131 125.5,122.5 R44.2 | U11.6 143.5,214
  Bottom 0.25: v145,131 145,213 143.5,213 143.5,214 U11.6 | R44.2 125.5,122.5 | R43.2 161,132.5
H5_BPF1
  Top 0.25: R36.1 118,173.5 118,172 137,172 137,173.5 141,173.5 C16.2 | R37.1 118,163
  Bottom 0.25: 118,173.5 118,163 R37.1 | R36.1 118,173.5 | C16.2 141,173.5 | 118,173.5 116.5,173.5 116.5,218 118,218 U10.1
H5_BPF2  (via drill 0.3 pad 0.6)
  Top 0.25: v140.5,150 140.5,150.5 125,150.5 125,151 124.5,151 124.5,151.5 124,151.5 124,153 | v140.5,144.5 153.5,144.5 153.5,143 | R40.1 118,143 | U10.7 125.5,216.5 | 124,153 118,153 R39.1 | R42.1 153.5,143 | v128,154.5 124,154.5 124,153 | TP10.1 153.5,102 | C18.2 141,153 | v156.5,143 153.5,143
  Bottom 0.25: U10.7 125.5,216.5 125.5,215.5 127,215.5 127,215 127.5,215 127.5,214.5 128,214.5 v128,154.5 | C18.2 141,153 141,144.5 v140.5,144.5 | R39.1 118,153 118,143 R40.1 | TP10.1 153.5,102 153.5,111 155,111 155,120 155.5,120 155.5,120.5 156,120.5 156,143 v156.5,143 | v140.5,150 141,150 | R42.1 153.5,143
H5_INV1
  Top 0.25: U10.2 118,216.5 | R36.2 125.5,173.5 134.5,173.5 134.5,174.5 158.5,174.5 158.5,173.5 C17.2
  Bottom 0.25: C17.2 158.5,173.5 | R36.2 125.5,173.5 119.5,173.5 119.5,215.5 118,215.5 118,216.5 U10.2
H5_INV2
  Top 0.25: R39.2 125.5,153 125.5,151.5 155,151.5 155,153 158.5,153 C19.2 | U10.6 125.5,214
  Bottom 0.25: C19.2 158.5,153 | U10.6 125.5,214 127,214 127,161.5 125.5,161.5 125.5,153 R39.2
H5_LP1  (via drill 0.3 pad 0.6)
  Top 0.25: RV15.2 115.5,132.5 | v138.5,214 136,214 U11.3 | v138.5,135.5 v134.5,135.5 115.5,135.5 115.5,132.5 | 115.5,132.5 113,132.5 RV15.3 | C20.1 136,132.5
  Bottom 0.25: RV15.2 115.5,132.5 | C20.1 136,132.5 134.5,132.5 v134.5,135.5 | U11.3 136,214 | RV15.3 113,132.5 | v138.5,214 v138.5,135.5
H5_LP2  (via drill 0.3 pad 0.6)
  Top 0.25: v148.5,114 121.5,114 121.5,112.5 118,112.5 C21.1 | v147,211.5 143.5,211.5 U11.5 | RV16.3 148.5,122.5 151,122.5 RV16.2
  Bottom 0.25: v148.5,114 148.5,122.5 | v147,211.5 147,122.5 148.5,122.5 | RV16.2 151,122.5 | RV16.3 148.5,122.5 | C21.1 118,112.5 | U11.5 143.5,211.5
H5_NEG
  Top 0.25: U12.1 153.5,219 | J3.3 118,97 152,97 152,103.5 153.5,103.5 153.5,112.5 R47.1
  Bottom 0.25: U12.1 153.5,219 155,219 155,121 153.5,121 153.5,112.5 R47.1 | J3.3 118,97
H5_NODE1  (via drill 0.3 pad 0.6)
  Top 0.25: C17.1 153.5,173.5 153.5,170.5 v135.5,170.5 | R35.1 136,183.5 125.5,183.5 R34.2 | C16.1 136,173.5
  Bottom 0.25: R34.2 125.5,183.5 | 136,173.5 136,170.5 v135.5,170.5 | 136,173.5 136,183.5 R35.1 | C17.1 153.5,173.5 | C16.1 136,173.5
H5_NODE2
  Top 0.25: R37.2 125.5,163 136,163 R38.1 | C18.1 136,153 136,154.5 142,154.5 142,153 153.5,153 C19.1
  Bottom 0.25: C19.1 153.5,153 | R38.1 136,163 136,153 C18.1 | R37.2 125.5,163
H5_OUT  (via drill 0.3 pad 0.6)
  Top 0.25: v162.5,92 136,92 TP12.1 | U12.6 161,214 | R64.1 130.5,33 | U12.7 161,216.5
  Bottom 0.25: 161,214 161,216.5 U12.7 | v162.5,92 162.5,214 161,214 | TP12.1 136,92 139.5,92 139.5,58.5 130.5,58.5 130.5,33 R64.1 | U12.6 161,214
H5_PHR1
  Top 0.25: R42.2 161,143 161,134 134.5,134 134.5,132.5 118,132.5 RV15.1
  Bottom 0.25: R42.2 161,143 | RV15.1 118,132.5
H5_PHR2
  Top 0.25: RV16.1 153.5,122.5 153.5,121 147,121 147,122.5 143.5,122.5 R45.2
  Bottom 0.25: R45.2 143.5,122.5 | RV16.1 153.5,122.5
H5_POLINV  (via drill 0.3 pad 0.6)
  Top 0.25: R47.2 161,112.5 161,114 152,114 152,112.5 143.5,112.5 R46.2 | v157,216.5 153.5,216.5 U12.2
  Bottom 0.25: R47.2 161,112.5 161,131 159.5,131 159.5,151.5 157,151.5 v157,216.5 | R46.2 143.5,112.5 | U12.2 153.5,216.5
H5_SELECT
  Top 0.25: RV17.1 136,102 136,99.5 118,99.5 J3.2
  Bottom 0.25: J3.2 118,99.5 | RV17.1 136,102
H5_TUNE1
  Top 0.25: RV13.1 153.5,183.5 153.5,182 147,182 147,183.5 143.5,183.5 R35.2
  Bottom 0.25: RV13.1 153.5,183.5 | R35.2 143.5,183.5
H5_TUNE2
  Top 0.25: RV14.1 153.5,163 153.5,161.5 147,161.5 147,163 143.5,163 R38.2
  Bottom 0.25: RV14.1 153.5,163 | R38.2 143.5,163
H7_AMPLITUDE  (via drill 0.3 pad 0.6)
  Top 0.25: RV22.2 188,102 | v188,210 210,210 210,211.5 216,211.5 U15.5
  Bottom 0.25: RV22.2 188,102 v188,210 | U15.5 216,211.5
H7_AP1  (via drill 0.3 pad 0.6)
  Top 0.25: U14.1 191,219 | R59.1 191,122.5 | v191,130.5 208.5,130.5 208.5,132.5 R57.1 | R55.1 191,143
  Bottom 0.25: 191,143 191,134 192,134 192,130.5 v191,130.5 191,122.5 R59.1 | R55.1 191,143 | 191,143 189.5,143 189.5,218 191,218 191,219 U14.1 | R57.1 208.5,132.5
H7_AP2  (via drill 0.3 pad 0.6)
  Top 0.25: v200,208.5 v195.5,208.5 | R60.1 191,112.5 | v191,120.5 191,121 179,121 179,122.5 173,122.5 R58.1 | U14.7 198.5,216.5 | J4.1 173,102
  Bottom 0.25: v195.5,208.5 195.5,216.5 198.5,216.5 U14.7 | R58.1 173,122.5 174.5,122.5 174.5,111 173,111 173,102 | v200,208.5 200,121 191,121 191,112.5 R60.1 | J4.1 173,102 | 173,102 171.5,102 171.5,95.5 173,95.5 TP14.1
H7_APINV1  (via drill 0.3 pad 0.6)
  Top 0.25: R55.2 198.5,143 v192.5,143 192.5,144.5 189.5,144.5 189.5,143 180.5,143 R54.2 | U14.2 191,216.5
  Bottom 0.25: v192.5,143 192.5,216.5 191,216.5 U14.2 | R54.2 180.5,143 | R55.2 198.5,143
H7_APINV2  (via drill 0.3 pad 0.6)
  Top 0.25: v197,124.5 197,124 | U14.6 198.5,214 | R58.2 180.5,122.5 189.5,122.5 189.5,124 216,124 216,132.5 R57.2
  Bottom 0.25: R58.2 180.5,122.5 | v197,124.5 197,213 198.5,213 198.5,214 U14.6 | R57.2 216,132.5
H7_BPF1
  Top 0.25: C22.2 196,173.5 192,173.5 192,172 173,172 173,173.5 R50.1 | R51.1 173,163
  Bottom 0.25: R51.1 173,163 173,173.5 | R50.1 173,173.5 | C22.2 196,173.5 | U13.1 171.5,219 171.5,182 173,182 173,173.5
H7_BPF2  (via drill 0.3 pad 0.6)
  Top 0.25: U13.7 180.5,216.5 180.5,215.5 179,215.5 179,215 v175,215 | R56.1 208.5,143 | v213.5,102 208.5,102 TP13.1 | 208.5,143 200,143 200,144.5 195.5,144.5 v195.5,150 173,150 173,153 R53.1 | v213.5,143 208.5,143 | R54.1 173,143 | C24.2 196,153
  Bottom 0.25: R56.1 208.5,143 | 173,153 173,161.5 174.5,161.5 174.5,215 v175,215 | v213.5,102 v213.5,143 | 173,153 173,143 R54.1 | TP13.1 208.5,102 | U13.7 180.5,216.5 | C24.2 196,153 195.5,153 v195.5,150 | R53.1 173,153
H7_INV1
  Top 0.25: R50.2 180.5,173.5 180.5,174.5 210,174.5 210,173.5 213.5,173.5 C23.2 | U13.2 173,216.5
  Bottom 0.25: U13.2 173,216.5 176.5,216.5 176.5,194.5 179,194.5 179,182 180.5,182 180.5,173.5 R50.2 | C23.2 213.5,173.5
H7_INV2
  Top 0.25: C25.2 213.5,153 210,153 210,154.5 180.5,154.5 180.5,153 R53.2 | U13.6 180.5,214
  Bottom 0.25: R53.2 180.5,153 180.5,161.5 182,161.5 182,214 180.5,214 U13.6 | C25.2 213.5,153
H7_LP1  (via drill 0.3 pad 0.6)
  Top 0.25: RV20.3 168,132.5 170.5,132.5 | v194,214 191,214 U14.3 | C26.1 191,132.5 | RV20.2 170.5,132.5 | 170.5,132.5 171.5,132.5 171.5,131.5 191,131.5 191,132.5 | 191,132.5 v194,132.5
  Bottom 0.25: U14.3 191,214 | RV20.3 168,132.5 | C26.1 191,132.5 | RV20.2 170.5,132.5 | v194,132.5 v194,214
H7_LP2  (via drill 0.3 pad 0.6)
  Top 0.25: RV21.3 203.5,122.5 206,122.5 RV21.2 | v203.5,114 176.5,114 176.5,112.5 173,112.5 C27.1 | U14.5 198.5,211.5
  Bottom 0.25: 203.5,122.5 203.5,161.5 202,161.5 202,211.5 198.5,211.5 U14.5 | RV21.2 206,122.5 | v203.5,114 203.5,122.5 | C27.1 173,112.5 | RV21.3 203.5,122.5
H7_NEG  (via drill 0.3 pad 0.6)
  Top 0.25: J4.3 173,97 v207,97 | U15.1 208.5,219 | R61.1 208.5,112.5
  Bottom 0.25: 208.5,112.5 208.5,113.5 210.5,113.5 210.5,114 211,114 211,219 208.5,219 U15.1 | 208.5,112.5 207,112.5 v207,97 | J4.3 173,97 | R61.1 208.5,112.5
H7_NODE1  (via drill 0.3 pad 0.6)
  Top 0.25: R49.1 191,183.5 180.5,183.5 R48.2 | C22.1 191,173.5 | v191,170.5 191,171 192.5,171 192.5,171.5 193,171.5 193,172 197,172 197,173.5 208.5,173.5 C23.1
  Bottom 0.25: R48.2 180.5,183.5 | C23.1 208.5,173.5 | R49.1 191,183.5 191,173.5 | C22.1 191,173.5 | v191,170.5 191,173.5
H7_NODE2
  Top 0.25: R51.2 180.5,163 191,163 R52.1 | C25.1 208.5,153 197,153 197,151.5 191,151.5 191,153 C24.1
  Bottom 0.25: R52.1 191,163 191,153 C24.1 | C25.1 208.5,153 | R51.2 180.5,163
H7_OUT  (via drill 0.3 pad 0.6)
  Top 0.25: U15.6 216,214 | 191,92 191,90.5 v150,90.5 | TP15.1 191,92 | U15.7 216,216.5 | 191,92 v212,92 | R65.1 148.5,33
  Bottom 0.25: R65.1 148.5,33 148.5,58.5 150,58.5 v150,90.5 | v212,92 212,214 216,214 | TP15.1 191,92 | 216,214 216,216.5 U15.7 | U15.6 216,214
H7_PHR1
  Top 0.25: RV20.1 173,132.5 189.5,132.5 189.5,134 216,134 216,143 R56.2
  Bottom 0.25: RV20.1 173,132.5 | R56.2 216,143
H7_PHR2
  Top 0.25: RV21.1 208.5,122.5 208.5,121 202,121 202,122.5 198.5,122.5 R59.2
  Bottom 0.25: RV21.1 208.5,122.5 | R59.2 198.5,122.5
H7_POLINV  (via drill 0.3 pad 0.6)
  Top 0.25: 210,112.5 210,111 198.5,111 198.5,112.5 R60.2 | v210,114.5 210,112.5 | 210,112.5 216,112.5 R61.2 | U15.2 208.5,216.5
  Bottom 0.25: U15.2 208.5,216.5 208.5,215.5 210,215.5 v210,114.5 | R61.2 216,112.5 | R60.2 198.5,112.5
H7_SELECT
  Top 0.25: J4.2 173,99.5 191,99.5 191,102 RV22.1
  Bottom 0.25: J4.2 173,99.5 | RV22.1 191,102
H7_TUNE1
  Top 0.25: R49.2 198.5,183.5 202,183.5 202,182 208.5,182 208.5,183.5 RV18.1
  Bottom 0.25: R49.2 198.5,183.5 | RV18.1 208.5,183.5
H7_TUNE2
  Top 0.25: R52.2 198.5,163 202,163 202,161.5 208.5,161.5 208.5,163 RV19.1
  Bottom 0.25: RV19.1 208.5,163 | R52.2 198.5,163
OUT
  Top 0.25: TP17.1 130.5,23 | 130.5,23 130.5,24.5 167.5,24.5 167.5,23 184,23 J6.1 | R69.2 102.5,23 111.5,23 111.5,21.5 130.5,21.5 130.5,23
  Bottom 0.25: R69.2 102.5,23 | J6.1 184,23 | TP17.1 130.5,23
RESTORE_INV
  Top 0.25: U16.6 17.5,28 17.5,29 19,29 19,31.5 185.5,31.5 185.5,33 191.5,33 | 191.5,33 191.5,31.5 203,31.5 203,33 209.5,33 R68.2 | R67.2 191.5,33
  Bottom 0.25: R67.2 191.5,33 | U16.6 17.5,28 | R68.2 209.5,33
SOURCE_WIPER
  Top 0.25: RV2.2 92.5,60 92.5,61 72,61 72,65 66,65 U3.3
  Bottom 0.25: RV2.2 92.5,60 | U3.3 66,65
SQ  (via drill 0.3 pad 0.6)
  Top 0.25: U3.2 66,67.5 | 118,185 69,185 69,183.5 63,183.5 | v97,60 113,60 R4.1 | R48.1 173,183.5 155,183.5 155,185 118,185 | 63,183.5 63,185 14,185 14,183.5 8,183.5 R6.1 | 118,185 118,183.5 R34.1 | TP2.1 166,60 | v166,63 v113,63 | R20.1 63,183.5
  Bottom 0.25: v66,183.5 U3.1 66,67.5 | v97,60 96.5,60 96.5,58.5 76,58.5 76,58 75.5,58 75.5,57.5 74.5,57.5 74.5,58 74,58 74,61 72,61 72,67.5 66,67.5 | R6.1 8,183.5 | TP2.1 166,60 v166,63 | R48.1 173,183.5 | U3.2 66,67.5 | R34.1 118,183.5 | v113,63 113,60 R4.1 | R20.1 63,183.5
SQ_INV  (via drill 0.3 pad 0.6)
  Top 0.25: 130.5,60 136.5,60 136.5,61.5 184,61.5 184,60 TP3.1 | 130.5,60 130.5,58.5 v75,58.5 | R5.1 130.5,60 | U3.7 73.5,67.5
  Bottom 0.25: U3.7 73.5,67.5 73.5,66.5 75,66.5 v75,58.5 | R5.1 130.5,60 | TP3.1 184,60
SQ_INV_IN  (via drill 0.3 pad 0.6)
  Top 0.25: R5.2 138,60 | v96.5,61.5 120.5,61.5 120.5,60 R4.2 | v93.5,65 73.5,65 U3.6
  Bottom 0.25: R5.2 138,60 132,60 132,61.5 129,61.5 129,60 120.5,60 R4.2 | v93.5,65 93.5,61.5 v96.5,61.5 | U3.6 73.5,65
SUM_INV  (via drill 0.3 pad 0.6)
  Top 0.25: R66.2 173.5,33 | R62.2 102.5,33 | v102.5,36 10,36 10,35.5 9.5,35.5 9.5,35 9,35 9,34.5 8.5,34.5 8.5,31.5 10,31.5 10,30.5 U16.2 | R65.2 156,33 | R63.2 120.5,33 | R64.2 138,33
  Bottom 0.25: R64.2 138,33 | 120.5,33 129,33 129,31.5 132,31.5 132,33 138,33 | R65.2 156,33 | 156,33 150,33 150,31.5 147,31.5 147,33 138,33 | R63.2 120.5,33 | 156,33 164.5,33 164.5,34.5 167.5,34.5 167.5,33 173.5,33 R66.2 | 102.5,33 111.5,33 111.5,31.5 114,31.5 114,33 120.5,33 | R62.2 102.5,33 | 102.5,33 v102.5,36 | U16.2 10,30.5
SUM_NEG
  Top 0.25: 166,33 166,34.5 175,34.5 175,33 184,33 R67.1 | R66.1 166,33 | 166,33 157.5,33 157.5,34.5 10,34.5 U16.1
  Bottom 0.25: R67.1 184,33 | R66.1 166,33
SUM_RAW  (via drill 0.3 pad 0.6)
  Top 0.25: R69.1 95,23 | 95,23 v19,23 | 113,23 112,23 112,24 104,24 104,24.5 95,24.5 95,23 | v201.5,25.5 113,25.5 113,23 | U16.7 17.5,30.5 | TP16.1 113,23 | R68.1 201.5,33
  Bottom 0.25: v19,23 19,30.5 17.5,30.5 U16.7 | TP16.1 113,23 | R68.1 201.5,33 v201.5,25.5 | R69.1 95,23
TIMING  (via drill 0.3 pad 0.6)
  Top 0.25: U1.6 17.5,65 | v19,76 v125.5,76 | U1.2 10,67.5 | RV1.3 125.5,70 128,70 RV1.2 | v132.5,70 148.5,70 C1.1
  Bottom 0.25: U1.6 17.5,65 17.5,66 | 17.5,66 19,66 v19,76 | v132.5,70 132,70 132,68.5 129,68.5 129,70 128,70 RV1.2 | U1.2 10,67.5 10,66.5 11.5,66.5 11.5,66 17.5,66 | RV1.3 125.5,70 v125.5,76 | C1.1 148.5,70
VCC  (via drill 0.3 pad 0.6)
  Top 0.25: R1.1 73.5,70 U3.8 | v125.5,201.5 136,201.5 136,204 | U12.8 161,219 | C38.1 43.5,204 43.5,205 29.5,205 29.5,204 26,204 | C28.1 201.5,23 185.5,23 185.5,19 167.5,19 167.5,22 166,22 166,23 J5.1 | 81,204 84.5,204 84.5,194.5 97,194.5 97,197.5 98.5,197.5 98.5,204 C44.1 | 33.5,219 42,219 42,220.5 51,220.5 51,219 | C48.1 136,204 | 106,219 106,220.5 97,220.5 97,219 88.5,219 | 180.5,220.5 171.5,220.5 171.5,219 161,219 | U2.10 45.5,60 | 106,219 116.5,219 116.5,220.5 125.5,220.5 125.5,219 | C40.1 63,204 v66,204 | U16.8 17.5,33 17.5,32 16,32 16,19 13.5,19 13.5,18 10,18 C58.1 | 26,204 26,197.5 24.5,197.5 24.5,194.5 11.5,194.5 11.5,204 8,204 C34.1 | U13.8 180.5,219 180.5,220.5 | U1.8 17.5,70 v34,70 | U9.8 106,219 | C54.1 191,204 | C36.1 26,204 | 88.5,219 88.5,220.5 79.5,220.5 79.5,219 70.5,219 | 33.5,219 33.5,220.5 24.5,220.5 24.5,219 15.5,219 U4.8 | U8.8 88.5,219 | 180.5,220.5 192,220.5 192,219 198.5,219 | C50.1 153.5,204 152,204 152,206.5 v151.5,206.5 | U1.4 10,62.5 | 191,204 v186.5,204 186.5,194.5 176.5,194.5 176.5,201.5 176,201.5 176,202 175.5,202 175.5,204 173,204 C52.1 | C46.1 118,204 v121,204 | 143.5,219 152,219 152,220.5 161,220.5 161,219 | v43.5,208.5 43.5,209 51.5,209 51.5,209.5 52,209.5 52,210 52.5,210 52.5,219 | v63,77.5 v73.5,77.5 | U15.8 216,219 210,219 210,220.5 198.5,220.5 198.5,219 | 70.5,219 70.5,220.5 61.5,220.5 61.5,219 51,219 | C56.1 208.5,204 198,204 198,202 197.5,202 197.5,201.5 197,201.5 197,194.5 192,194.5 192,197.5 191,197.5 191,204 | U14.8 198.5,219 | v66,193 79.5,193 79.5,197.5 81,197.5 81,204 | 125.5,219 134.5,219 134.5,220.5 143.5,220.5 143.5,219 | 152,205 139.5,205 139.5,204 136,204
  Top 0.25: U7.8 70.5,219 | U6.8 51,219 | U11.8 143.5,219 | C42.1 81,204 | U5.8 33.5,219 | U2.14 45.5,70 50.5,70 C31.1 | v166,30 v98.5,30 | C32.1 66,55 | U10.8 125.5,219 | C30.1 10,55
  Bottom 0.25: 10,62.5 10,63.5 8.5,63.5 8.5,71.5 11.5,71.5 11.5,70 17.5,70 U1.8 | 44,70 44,61 45.5,61 45.5,60 U2.10 | U16.8 17.5,33 17.5,53.5 13.5,53.5 13.5,55 10,55 | v34,70 36.5,70 36.5,71.5 37,71.5 37,74 37.5,74 37.5,74.5 38.5,74.5 38.5,74 39,74 39,71.5 39.5,71.5 39.5,70 44,70 | C44.1 98.5,204 98.5,207.5 98,207.5 98,208 97.5,208 97.5,210 97,210 97,219 v96.5,219 | C34.1 8,204 | U5.8 33.5,219 | C31.1 50.5,70 54,70 54,68.5 57,68.5 57,69 63.5,69 | J5.1 166,23 v166,30 | C40.1 63,204 | U9.8 106,219 | C56.1 208.5,204 | C46.1 118,204 | U15.8 216,219 | C36.1 26,204 | U10.8 125.5,219 | C42.1 81,204 | C28.1 201.5,23 | C32.1 66,55 66,61 64.5,61 64.5,62.5 64,62.5 64,63 63.5,63 63.5,77.5 v63,77.5 | U13.8 180.5,219 | C38.1 43.5,204 v43.5,208.5 | U14.8 198.5,219 | v66,204 v66,193 | U11.8 143.5,219 | 44,70 45.5,70 U2.14 | C58.1 10,18 | C30.1 10,55 | C50.1 153.5,204 | C54.1 191,204 | U1.4 10,62.5 | U12.8 161,219 | v98.5,30 98.5,70 R1.1 | U8.8 88.5,219 | v186.5,204 v186.5,220.5 | U4.8 15.5,219 | C52.1 173,204 | U7.8 70.5,219 | v73.5,193 73.5,70 U3.8 | v121,204 121.5,204 121.5,202.5 125.5,202.5 v125.5,201.5 | U6.8 51,219 | v151.5,206.5 v151.5,219 | C48.1 136,204 | 10,55 10,62.5
VEE  (via drill 0.3 pad 0.6)
  Top 0.25: v11.5,45.5 71,45.5 71,47 | 48.5,196 61.5,196 61.5,194.5 68,194.5 68,196 | v81,208.5 v98.5,208.5 118,208.5 118,211.5 | C37.2 31,196 42,196 42,197.5 48.5,197.5 48.5,196 | 104.5,208.5 104.5,205 105,205 105,202.5 103.5,202.5 103.5,196 C45.2 | C59.2 15,10 | U9.4 98.5,211.5 | J5.3 166,18 v97,18 | v26,206.5 47,206.5 | U13.4 173,211.5 | 173,211.5 173,210 182,210 182,211.5 191,211.5 U14.4 | C47.2 123,196 124,196 124,202.5 124.5,202.5 124.5,210 | 153.5,209 132.5,209 132.5,209.5 132,209.5 132,211.5 136,211.5 U11.4 | v64.5,109.5 v69.5,109.5 | 14,210 14,211.5 8,211.5 U4.4 | 153.5,209 161.5,209 161.5,209.5 162,209.5 162,210 162.5,210 162.5,211.5 173,211.5 | 118,211.5 124,211.5 124,210 132,210 | U12.4 153.5,211.5 | v191,207.5 v208.5,207.5 208.5,205 210,205 210,196 213.5,196 C57.2 | U3.4 66,62.5 | C55.2 196,196 196,202.5 197,202.5 197,207.5 | 86,208.5 86,205 87,205 87,202.5 86,202.5 86,196 C43.2 | 14,210 22,210 22,210.5 22.5,210.5 22.5,211 26,211 26,211.5 U5.4 | 14,210 14,205 14.5,205 14.5,202.5 14,202.5 14,196 13,196 C35.2 | 153,197.5 153,198 v152,198 | C33.2 71,47 | 47,206.5 47,197.5 | C49.2 141,196 141,197.5 155,197.5 155,196 158.5,196 C51.2 | v97,47 71,47 | C29.2 97,12.5 | v49,211.5 43.5,211.5 U6.4 | U8.4 81,211.5 81,211 77.5,211 77.5,210.5 77,210.5 77,210 69,210 69,211.5 63,211.5 U7.4 | 177.5,210 177.5,205 176.5,205 176.5,202.5 178,202.5 178,196 C53.2 | C41.2 68,196 | C39.2 48.5,196 | 69.5,210 69.5,202.5 69,202.5 69,196 68,196 | 153.5,209 v153.5,208.5 | U10.4 118,211.5 | U16.4 10,25.5 | U15.4 208.5,211.5 | v49.5,206.5 47,206.5
  Bottom 0.25: v64.5,109.5 64.5,63.5 66,63.5 66,62.5 | 11.5,26.5 13.5,26.5 13.5,16.5 15,16.5 15,10 C59.2 | v191,207.5 191,211.5 U14.4 | 66,62.5 69.5,62.5 69.5,53.5 71,53.5 71,47 C33.2 | v152,198 152,205 153.5,205 153.5,211.5 U12.4 | 11.5,26.5 10,26.5 10,25.5 U16.4 | U6.4 43.5,211.5 | v26,206.5 26,211.5 U5.4 | C51.2 158.5,196 | v81,208.5 81,211.5 U8.4 | U3.4 66,62.5 | 11.5,26.5 v11.5,45.5 | v208.5,207.5 208.5,211.5 U15.4 | C41.2 68,196 68,155 68.5,155 68.5,154.5 69,154.5 69,121 69.5,121 v69.5,109.5 | C37.2 31,196 | C35.2 13,196 | U7.4 63,211.5 | C57.2 213.5,196 | U10.4 118,211.5 | v98.5,208.5 98.5,211.5 U9.4 | U11.4 136,211.5 | v49.5,206.5 49,206.5 v49,211.5 | C55.2 196,196 | v97,47 97,12.5 C29.2 | U13.4 173,211.5 | C39.2 48.5,196 | U4.4 8,211.5 | C43.2 86,196 | C47.2 123,196 | C49.2 141,196 | J5.3 166,18 | C45.2 103.5,196 | C53.2 178,196